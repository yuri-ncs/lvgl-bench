## v9/sdkconfig.defaults
```kconfig
# libc malloc/memcpy, as in v8
CONFIG_LV_USE_CLIB_MALLOC=y
CONFIG_LV_USE_CLIB_STRING=y
```
